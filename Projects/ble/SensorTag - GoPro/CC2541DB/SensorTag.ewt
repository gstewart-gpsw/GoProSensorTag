<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC2541DK-Sensor</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CC2541DK-Sensor-OAD-ImgA</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CC2541DK-Sensor-OAD-ImgB</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\Source\OSAL_SensorTag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SensorTag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\sensorTag.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SensorTag_Main.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\common\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\services\saddr\saddr.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>Config</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_board_cfg.h</name>
        </file>
      </group>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_acc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_assert.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_bar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_gyro.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_humi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_interrupt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_irtemp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_keys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_mag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_startup.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_timer.c</name>
        </file>
      </group>
      <group>
        <name>Includes</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_acc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_aes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_bar.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_gyro.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_humi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_irtemp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_keys.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_mag.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_sensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2541ST\hal_types.h</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2541DB\bin\CC2541_BLE_peri.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_None.lib</name>
    </file>
  </group>
  <group>
    <name>NPI</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.h</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\bcomdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_bufmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_cbtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_ClockBLE.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\mcu\cc2540\osal_snv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
  </group>
  <group>
    <name>PROFILES</name>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\accelerometerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\accelerometerservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\barometerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\barometerservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\ccservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\ccservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\devinfoservice-st.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\devinfoservice-st.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gapgattserver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\host\gatt_uuid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gattservapp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\goproService.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\goproService.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\gyroservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\gyroservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\humidityservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\humidityservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\irtempservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\irtempservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\magnetometerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\magnetometerservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\OAD\oad.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\OAD\oad_target.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\OAD\oad_target.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\peripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\peripheral.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Keys\simplekeys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Keys\simplekeys.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\st_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\st_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\testservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\testservice.h</name>
    </file>
  </group>
  <group>
    <name>TOOLS</name>
    <file>
      <name>$PROJ_DIR$\..\..\config\buildComponents.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\buildConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.h</name>
    </file>
  </group>
</project>


